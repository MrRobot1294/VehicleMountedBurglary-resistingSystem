# Keil uVision project Send.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Send +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\NRF24L01;.\Delay;.\uart;.\ESP8266
  group Source Group 1
    ./: STARTUP.A51 Send.c
    ./Delay/: Delay.c
    ./NRF24L01/: NRF24L01.c
    ./uart/: uart.c
    ./ESP8266/: ESP8266.c
