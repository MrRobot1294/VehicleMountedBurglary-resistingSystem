# Keil uVision project car.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: car +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Delay;.\LCD;.\uart;.\gps;.\gsm900c;.\uart2_STC12C5A60S2;.\NRF24L01;..\车载防盗
  group Source Group 1
    ./: STARTUP.A51 car.c
    ./Delay/: Delay.c
    ./LCD/: LCD.c
    ./uart/: uart.c
    ./gps/: gps.c
    ./gsm900c/: gsm900c.c
    ./uart2_STC12C5A60S2/: uart2_STC12C5A60S2.c
    ./NRF24L01/: NRF24L01.c
